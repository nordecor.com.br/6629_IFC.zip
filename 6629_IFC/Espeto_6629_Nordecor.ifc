Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-10-06T13:01:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 06 13:01:05 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\b647a73c-8b04-435e-ab28-770fdfd840cf\61b073be-6912-4000-9a59-eba3a72cd114\ifc * Database version: 5507 * Database creation date: Mon Oct 06 13:01:01 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 06 13:01:02 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 06 13:01:02 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_331530
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6628, Espeto_6629_Nordecor_IFC:6628:331530
In: Nível 1
Type - Material: Plástico - Transparente, Metal - Alumínio - Preto, LED
Type - Cotas - Altura espeto: 400 mm; Diâmetro projetor: 50 mm
Type - Dados - Data de atualização: 02/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: espeto de jardim, LED, 7W, 2700K, 24º, iluminação externa, acabamento preto, paisagismo, facho concentrado; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Espeto de jardim DAYA acabamento preto, LED 10W 2.700K 24º; Descrição UniFormat: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 66; Localização: Itajaí/SC - Brasil; Modelo: 6629; Nome do tipo: 6628; Nota-chave: 26 56 36.23; Número MasterFormat: 26 56 36; Número OmniClass: 23.80.70.14.14; Tipo de imagem: Imagem raster: 6629.png; Tipo de luminária: Distribuição Direcional / Facho concentrado (24º); Título MasterFormat: Luminárias de Paisagismo; Título OmniClass: Exterior Floodlights; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/espeto-led-daya-10w-2-700k-irc97/
Type - Elétrico - Comentários de voltagem: 100-240V; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente: 0 W; Carga aparente da luminária: 0 W
Type - Engenharia elétrica - Fator de potência da luminária: 1; Voltagem da Luminária: 127 V
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Ângulo de abertura: 24 deg; Fluxo luminoso: 830 lm; IRC: 97; Potência: 10 W; Temperatura da cor: 2700 K; UGR: 13
Type - Materiais e acabamentos - Difusor: Plástico - Transparente; Espeto: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Nome da família: Espeto_6629_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6628; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Altura colocação do espeto: 803 mm; Altura do espeto: 803 mm; Área: 0.0269553 m2; Inclinação do projetor: 45 deg; Rotação do projetor: 90 deg; Volume: 0.000334131 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 127 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Espeto_6629_Nordecor_IFC: 6628; Família e tipo: Espeto_6629_Nordecor_IFC: 6628; ID de tipo: Espeto_6629_Nordecor_IFC: 6628; Tipo: Espeto_6629_Nordecor_IFC: 6628
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
